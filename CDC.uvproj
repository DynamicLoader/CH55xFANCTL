# Keil uVision project CDC.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CDC +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Public
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: CDC.C DataFlash.C PWM.C DS18B20.c Main.C Timer.C SerialLCD.C KEY.C
    ./Public/: DEBUG.C
